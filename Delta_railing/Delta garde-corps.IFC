Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta garde-corps.IFC
Time: 2020-07-01T13:19:01
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DELT-GAR-GRI-MU-015
In: Default Storey
Material: S235

# IfcBuildingElementProxy: DELT-GAR-GRI-MU-001_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 28.9435; Area Measure: 2.38957; Volume Measure: 0.00535249

# IfcBuildingElementProxy: DELT-GAR-GRI-MU-015
In: Default Storey
Material: S235

# IfcBuildingElementProxy: DELT-GAR-GRI-MU-020_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: DELT-GAR-GRI-MU-022_Default
In: Default Storey
Material: S 235
